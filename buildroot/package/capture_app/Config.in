## buildroot/package/capture_app/Config.in
```kconfig
config BR2_PACKAGE_CAPTURE_APP
    bool "capture_app"
    help
      This is the capture application for image processing.
```
